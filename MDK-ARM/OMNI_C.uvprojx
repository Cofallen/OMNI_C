# Keil uVision project OMNI_C.uvprojx, settings and files
target OMNI_C (6180000::V6.18::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: OMNI_C +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Bsp/ctl/inc;../Bsp/dev/inc;../Bsp/extra/inc;../LIB;../JUDGE;../CMSIS/Core/Inc;../CMSIS/DSP/Inc/dsp;../CMSIS/DSP/Inc;../CMSIS/DSP/PrivateInclude;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ../Core/Inc;..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group ctl
    ../Bsp/ctl/src/: ATTACK.c CAP.c CHASSIS.c DBUS.c GIMBAL.c MOTOR.c YU_PID.c TOP.c
  group dev
    ../Bsp/dev/src/: TIM_DEV.c CAN_DEV.c USART_DEV.c
    ./: USB_DEV.c
  group extra
    ../Bsp/extra/src/: JUDGEMENT.c VISION.c VOFA.c YU_MATH.c ROOT.c
  group LIB
    ../LIB/: BMI088driver.c BMI088driver.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h bsp_imu_pwm.c bsp_imu_pwm.h kalman_filter.c kalman_filter.h QuaternionEKF.c QuaternionEKF.h struct_typedef.h user_lib.c user_lib.h imu_temp_control_task.c imu_temp_control_task.h pid.c pid.h
  group JUDGE
    ../JUDGE/: CRC_DJI.c Read_Data.c Write_Data.c Anonymity_TX.c
  group CMSIS
    ../CMSIS/DSP/Src/BasicMathFunctions/: BasicMathFunctions.c
    ../CMSIS/DSP/Src/BayesFunctions/: BayesFunctions.c
    ../CMSIS/DSP/Src/CommonTables/: CommonTables.c
    ../CMSIS/DSP/Src/ComplexMathFunctions/: ComplexMathFunctions.c
    ../CMSIS/DSP/Src/ControllerFunctions/: ControllerFunctions.c
    ../CMSIS/DSP/Src/DistanceFunctions/: DistanceFunctions.c
    ../CMSIS/DSP/Src/FastMathFunctions/: FastMathFunctions.c
    ../CMSIS/DSP/Src/FilteringFunctions/: FilteringFunctions.c
    ../CMSIS/DSP/Src/InterpolationFunctions/: InterpolationFunctions.c
    ../CMSIS/DSP/Src/MatrixFunctions/: MatrixFunctions.c
    ../CMSIS/DSP/Src/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../CMSIS/DSP/Src/StatisticsFunctions/: StatisticsFunctions.c
    ../CMSIS/DSP/Src/SupportFunctions/: SupportFunctions.c
    ../CMSIS/DSP/Src/SVMFunctions/: SVMFunctions.c
    ../CMSIS/DSP/Src/TransformFunctions/: TransformFunctions.c
    ../CMSIS/DSP/Src/WindowFunctions/: WindowFunctions.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../LIB/: usbd_cdc_if.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group UI
    ../UI/: ui_default_init0_0.c ui_default_init0_1.c ui_default_init0_2.c ui_default_init1_0.c ui_default_init2_0.c ui_default_init3_0.c ui_default_init4_0.c ui_default_init5_0.c ui_default_init5_1.c ui_default_init5_2.c ui_default_init5_3.c ui_default_init6_0.c ui_interface.c
